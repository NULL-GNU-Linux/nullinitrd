## config.defconfig
```kconfig
CONFIG_STATIC=y
CONFIG_DEBUG=n
CONFIG_LTO=y
CONFIG_FEATURE_LVM=n
CONFIG_FEATURE_LUKS=n
CONFIG_FEATURE_MDADM=n
CONFIG_FEATURE_BTRFS=n
CONFIG_FEATURE_ZFS=n
```
